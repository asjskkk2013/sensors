# IAR project Exp10.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F64 CC2530F64
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F64.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    uart/: hal_uart.c
    ./: HMC5883_I2C.h HMC5883L.c main.c MPU6050.c ms5611.c
    iic/: iic.c
